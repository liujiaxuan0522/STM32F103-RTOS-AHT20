# Keil uVision project RTOS.uvprojx, settings and files
target RTOS (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;../Middlewares/uC-CPU;../Middlewares/uC-CPU/ARM-Cortex-M/ARMv7-M;../Middlewares/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM;../Middlewares/uC-LIB;../Middlewares/uC-OS3/Source;../Middlewares/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M;../Middlewares/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM
  asm include: ../App;../Middlewares/uC-CPU;../Middlewares/uC-CPU/ARM-Cortex-M/ARMv7-M;../Middlewares/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM;../Middlewares/uC-LIB;../Middlewares/uC-OS3/Source;../Middlewares/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M;../Middlewares/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group uC-CPU
    ../Middlewares/uC-CPU/: cpu_core.c
    ../Middlewares/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../Middlewares/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group uC-LIB
    ../Middlewares/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC-OS3
    ../Middlewares/uC-OS3/Source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC-OS3-Port
    ../Middlewares/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../Middlewares/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
  group App
    ../App/: app.c
software components: CMSIS:CORE 5.6.0
